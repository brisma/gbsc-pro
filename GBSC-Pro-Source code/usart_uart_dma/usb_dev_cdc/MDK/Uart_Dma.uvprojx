# Keil uVision project Uart_Dma.uvprojx, settings and files
target Uart_Dma_Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003C0) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: u_dma +hex
  AfterMake: fromelf  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=2
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,_PLATFORM_ARM_
  c include: ../source;../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../drivers/cmsis/Include;../../drivers/hc32_ll_driver/inc;../../drivers/bsp/ev_hc32f460_lqfp100_v2;../../midwares/hc32/usb;../../midwares/hc32/usb/usb_device_lib/device_core;../../midwares/hc32/usb/usb_device_lib/device_class/single_cdc;..\APP;..\cm_backtrace
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x60000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group driver
    ../../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_clk.c hc32_ll_efm.c hc32_ll_gpio.c hc32_ll_interrupts.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_crc.c hc32_ll_fcg.c hc32_ll_tmr0.c hc32_ll_i2c.c hc32_ll_fcm.c hc32_ll_icg.c hc32_ll_aos.c hc32_ll_dma.c
  group ev_hc32f460_lqfp100_v2
    ../../drivers/bsp/ev_hc32f460_lqfp100_v2/: ev_hc32f460_lqfp100_v2.c
  group APP
    ../source/: main.c flash.c i2c.c uart_dma.c videoprocess.c
  group cmsis
    ../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
    ./: startup_hc32f460.s
  group cm_backtrace
    ../cm_backtrace/: cm_backtrace.c
    ../cm_backtrace/fault_handler/keil/: cmb_fault.S
target Uart_Dma_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: usb_dev_cdc +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F460,USE_DDL_DRIVER,
  c include: ..\source;../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../../../../drivers/cmsis/Include;../../../../../../drivers/hc32_ll_driver/inc;../../../../../../drivers/bsp/ev_hc32f460_lqfp100_v2;../../../../../../midwares/hc32/usb;../../../../../../midwares/hc32/usb/usb_device_lib/device_core;../../../../../../midwares/hc32/usb/usb_device_lib/device_class/single_cdc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
